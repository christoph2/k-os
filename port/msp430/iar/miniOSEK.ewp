# IAR project miniOSEK.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2013 MSP430F2013
  General.GStackSize2: 50
  General.GHeapSize2: 0
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  group (top)
    ../../../: app.c com_if.c com_int.c Os.c os_alm.c Os_Cfg.c os_ctr.c Os_Error.c os_evt.c os_exec.c os_intr.c os_mlq.c os_orti.c os_pq.c os_res.c Os_SchT.c os_task.c os_util.c os_vars.c
