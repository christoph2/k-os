# IAR project EX01.ewp, settings and files
configuration Debug (68HC12, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlhcs12nfn.h
  General.GHeapSize: 512
  General.GStackSize: 64
  General.OGChipSelectMenu: mc9s12dp256b MC9S12DP256B
  ICC6812.CCIncludePath2: C:\projekte\csProjects\k-os\inc; C:\projekte\csProjects\common\inc; C:\projekte\csProjects\common; C:\projekte\csProjects\common\InstallISR; C:\projekte\csProjects\k-os\examples\Ex01; C:\projekte\csProjects\common\drivers\include\cpu12
  ICC6812.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  A6812.ADefines: __NORMAL_MODEL__
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkmc9s12dp256b.xcl
configuration Release (68HC12)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: hcs12
  ICC6812.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: app.c Hw_Cfg.c Os_Cfg.c
    ../../../../common/src/: Utl.c
  group OSEK
    ../../../src/: Com_Ext.c Com_Flt.c Com_If.c Com_Int.c Os_Alm.c Os_Ctr.c Os_Error.c Os_Evt.c Os_Exec.c Os_Intr.c Os_Mlq.c Os_Orti.c Os_Port.c Os_Res.c Os_SchT.c Os_Task.c Os_Vars.c
    ../../../../common/InstallISR/: ISR.c
    ../../../port/cpu12/iar/: Port_Asm.asm
